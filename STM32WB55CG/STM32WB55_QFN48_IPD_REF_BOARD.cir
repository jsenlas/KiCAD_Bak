.title KiCad schematic
C14 Net-_C14-Pad1_ GND 10n
C15 3v3fromUSB GND 100n
C16 3v3fromUSB GND 1u
FB1 +3V3 Net-_C3-Pad1_ Z0805C601BSMST
C3 Net-_C3-Pad1_ GND 100n
C2 +3V3 GND 100p
C1 +3V3 GND 100n
C6 +3V3 GND 100n
Y1 Net-_U2-Pad24_ Net-_U2-Pad25_ GND NX2520SA-32MHz
C18 Net-_C18-Pad1_ GND 4p3
C17 Net-_C17-Pad1_ GND 4p3
Y2 Net-_C18-Pad1_ Net-_C17-Pad1_ NX2012SA-32768K
R4 Net-_R4-Pad1_ GND 10K
C19 Net-_C19-Pad1_ GND 100n
D2 NRST Net-_C19-Pad1_ BAT54J
R5 +3V3 Net-_C19-Pad1_ 100K
R2 +3V3 I2C_SDA 10K
R3 +3V3 I2C_SCL 10K
C13 Net-_C13-Pad1_ GND 4u7
C_1 3v3fromBAT GND 10u
L1 +1V5 Net-_L1-Pad2_ 4u7
BT1 +1V5 GND Battery_Cell
C5 +1V5 GND 4u7
R_2 Net-_R_1-Pad2_ GND 562k
R_1 3v3fromBAT Net-_R_1-Pad2_ 976k
U1 Net-_L1-Pad2_ GND +1V5 Net-_R_1-Pad2_ 3v3fromBAT +1V5 MCP1640CCH
R13 Net-_R13-Pad1_ GND 10K
R12 +3V3 ADC_ALERT 10K
C22 GND Net-_C22-Pad2_ 1u
C20 GND +3V3 1u
FB2 +3V3 Net-_C22-Pad2_ MMZ2012Y152BTD25
U5 Net-_R13-Pad1_ ADC_ALERT Net-_FB3-Pad1_ Net-_J4-Pad2_ Net-_J4-Pad3_ Net-_J4-Pad4_ NC_01 Net-_C22-Pad2_ I2C_SDA I2C_SCL ADS1115IDGS
IC2 USB_D- GND USB_D+ Net-_IC2-Pad4_ +5V Net-_IC2-Pad6_ USBLC6-2SC6
C11 +5V GND 1u
IC1 +5V GND +5V Net-_C14-Pad1_ 3v3fromUSB LD3985M33R
C12 +5V GND 100n
R1 LED_BLUE Net-_D1-Pad2_ 100K
U2 +3V3 Net-_C17-Pad1_ Net-_C18-Pad1_ Net-_R4-Pad1_ I2C_SCL I2C_SDA Net-_C19-Pad1_ Net-_C3-Pad1_ NC_02 SPI_SCK NC_03 NC_04 LED_BLUE GENERAL_PIN_OUT1 SPI_MISO SPI_MOSI NC_05 NC_06 NC_07 +3V3 RF1 GND +3V3 Net-_U2-Pad24_ Net-_U2-Pad25_ NC_08 NC_09 NC_10 NC_11 Net-_C13-Pad1_ GND Net-_L3-Pad2_ +3V3 +3V3 NC_12 USB_D- USB_D+ SYS_JTMS-SWDIO +3V3 SYS_JTCK-SWCLK NC_13 SYS_JTDO-SWO GENERAL_PIN_OUT2 GENERAL_PIN_OUT3 ADC_ALERT BNO055_INT +3V3 STM32WB55CG
D1 GND Net-_D1-Pad2_ LED Blue
U3 NC_14 +3V3 Net-_R4-Pad1_ NC_15 3v3fromUSB +3V3 3v3fromBAT NC_16 MLL1200S TE
FL1 Net-_FL1-Pad1_ GND RF1 GND GND GND MLPF-WB55-01E3
ed1 GND GND Net-_FL1-Pad1_ RECE.20279.001E.01
C4 +3V3 GND 4u7
C7 +3V3 GND 100n
C8 +3V3 GND 100n
C9 +3V3 GND 100n
C10 +3V3 GND 100n
C24 Net-_C24-Pad1_ GND 22p
R6 +3V3 Net-_D3-Pad2_ 10K
J1 +5V Net-_IC2-Pad6_ Net-_IC2-Pad4_ NC_17 GND GND USB_B_Micro
L2 Net-_C13-Pad1_ Net-_L2-Pad2_ 10u
JP1 Net-_C13-Pad1_ +3V3 SolderJumper Open
C21 +3V3 GND 100n
R10 Net-_R10-Pad1_ GND 10K
R11 Net-_R11-Pad1_ GND 10K
C23 Net-_C23-Pad1_ GND 1u
Y3 Net-_C24-Pad1_ Net-_C25-Pad1_ NX2012SA-32768K
C25 Net-_C25-Pad1_ GND 22p
U4 NC_18 GND +3V3 +3V3 Net-_R10-Pad1_ Net-_R11-Pad1_ NC_19 NC_20 Net-_C23-Pad1_ GND Net-_D3-Pad2_ NC_21 NC_22 BNO055_INT GND GND GND GND I2C_SCL I2C_SDA NC_23 NC_24 NC_25 NC_26 GND Net-_C24-Pad1_ Net-_C25-Pad1_ +3V3 BNO055_my
R9 Net-_J4-Pad2_ GND 100K
R8 Net-_J4-Pad3_ GND 100K
R7 Net-_J4-Pad4_ GND 100K
J4 +3V3 Net-_J4-Pad2_ Net-_J4-Pad3_ Net-_J4-Pad4_ Conn_01x04_Male
D3 BNO055_RESET Net-_D3-Pad2_ 1N4148WT
J2 SPI_MOSI SPI_MISO SPI_SCK BNO055_RESET I2C_SCL I2C_SDA Conn_01x06_Male
L3 Net-_L2-Pad2_ Net-_L3-Pad2_ 10n
J3 GENERAL_PIN_OUT3 GENERAL_PIN_OUT2 GENERAL_PIN_OUT1 Conn_01x03_Male
J5 +3V3 NRST SYS_JTMS-SWDIO SYS_JTCK-SWCLK SYS_JTDO-SWO GND Conn_01x06_Male
FB3 Net-_FB3-Pad1_ GND MMZ2012Y152BTD25
.end
